# Keil uVision project RT1052.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: RT1052
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CPU_MIMXRT1052DVL6B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1,SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\drivers;..\..\Libraries\utilities;..\..\Libraries\utilities\io;..\..\Libraries\utilities\log;..\..\Libraries\utilities\str;..\..\User\xip;..\..\User\bsp;..\..\User;..\..\Libraries\hardware;..\..\Libraries\hardware\lcd;..\..\Libraries\hardware\font
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
  group CMSIS
    ../../Libraries/: system_MIMXRT1052.c
  group startup
    ./: startup_MIMXRT1052.s
  group drivers
    ../../Libraries/drivers/: fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_common.c fsl_pit.c fsl_lpi2c.c fsl_pxp.c fsl_elcdif.c fsl_adc.c
  group utilities
    ../../Libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_shell.c fsl_sbrk.c fsl_debug_console.c
    ../../Libraries/utilities/str/: fsl_str.c
    ../../Libraries/utilities/log/: fsl_log.c
    ../../Libraries/utilities/io/: fsl_io.c
  group board
    ../../User/: board.c clock_config.c pin_mux.c
  group hardware
    ../../Libraries/hardware/: pit.c led.c key.c systick.c nvic.c i2c.c adc.c
    ../../Libraries/hardware/lcd/: bsp_lcd.c
    ../../Libraries/hardware/font/: fonts.c
  group user
    ../../User/: main.c
  group xip
    ../../User/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
